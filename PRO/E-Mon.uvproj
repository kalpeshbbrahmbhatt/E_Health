# Keil uVision project E-Mon.uvproj, settings and files
target E-Mon (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: E-Mon +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\STM32Lib;..\STM32LibStartUp
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../STM32Lib/StartUp/: startup_stm32f10x_md.s
  group User
    ../USER/: main.c stm32f10x_it.c usart1.c config.c E_MON.c
  group CMSIS
    ../STM32Lib/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../STM32Lib/: stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
